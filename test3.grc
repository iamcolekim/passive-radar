options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LP_c
  id: variable_qtgui_range
  parameters:
    label: LP_c
    rangeType: int
    start: '1'
    step: int(samp_rate/20)
    stop: int(samp_rate/2)
    value: int(3e6)
  states: {}
- name: N
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 99.1e6
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    start: '0'
    step: 1e3
    stop: 16e3
    value: '0'
  states: {}
- name: mult
  id: variable_qtgui_range
  parameters:
    label: mult
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '12344'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_correctiq_1
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\david\ece496\passive-radar\9f.cs8
    length: 8*int(samp_rate)
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\david\ece496\passive-radar\63.cs8
    length: 8*int(samp_rate)
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: average
    max_iter: '4000'
    scale: 1/average
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average
    max_iter: '4000'
    scale: 1/average
    type: complex
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: mult
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LP_c
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LP_c
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=000000000000000066a062dc226b169f"'
    bb_gain0: '20'
    freq0: channel_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0000000000000000436c63dc38284c63"'
    bb_gain0: '20'
    freq0: channel_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: N
    srate: samp_rate
    type: float
    ymax: 2e10
    ymin: '0'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_noise_source_x_0, '0', dc_blocker_xx_0_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_sub_xx_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_correctiq_1, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_correctiq_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_sub_xx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_vector_to_stream_0_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_0_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_stream_to_vector_0_2_0, '0', fft_vxx_0_1, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_sub_xx_0_0, '0', blocks_correctiq_1, '0']
- [blocks_sub_xx_0_0, '0', dc_blocker_xx_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', blocks_stream_to_vector_0_2_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_delay_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [dc_blocker_xx_0_0, '0', low_pass_filter_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_1, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [osmosdr_source_0, '0', blocks_sub_xx_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_sub_xx_0, '1']
- [osmosdr_source_0_0, '0', blocks_sub_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
