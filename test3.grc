options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: centre_freq
  id: variable
  parameters:
    value: 1e9
  states: {state: disabled}
- name: centre_freq
  id: variable_qtgui_range
  parameters:
    start: 800e6
    step: 20e6
    stop: 2700e6
    value: 800e6
  states: {state: disabled}
- name: channel_freq
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    start: '0'
    step: '10'
    stop: '1000000'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Centre Frequency
    start: 87.9e6
    step: 200e3
    stop: 107.9e6
    value: 88.1e6
  states: {}
- name: mult
  id: variable_qtgui_range
  parameters:
    label: mult
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,10
    label: Volume (dB)
    start: '-100'
    step: '0.1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '4'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '10'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq-channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_correctiq_0_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /Users/ibrahimsweidan/Downloads/63.cs8
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /Users/ibrahimsweidan/Downloads/9f.cs8
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'True'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(volume/20)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: mult
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '48000'
    decim: '40'
    gain: '1'
    samp_rate: 5e6
    type: fir_filter_ccf
    width: '25000'
    win: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '40'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '25000'
    win: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=000000000000000066a062dc226b169f"'
    bb_gain0: '20'
    freq0: centre_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0000000000000000436c63dc38284c63"'
    bb_gain0: '20'
    freq0: centre_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: N
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: N
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: N
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: N
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_0_2_1, '0']
- [analog_noise_source_x_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [analog_noise_source_x_0_0, '0', qtgui_freq_sink_x_0_2_0, '0']
- [analog_noise_source_x_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0_2, '0']
- [blocks_correctiq_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_correctiq_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_correctiq_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_sub_xx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_freq_sink_x_0_4, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_sub_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_correctiq_0_0, '0']
- [blocks_sub_xx_0_0, '0', dc_blocker_xx_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_freq_sink_x_0_3, '0']
- [blocks_vector_to_stream_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_delay_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
