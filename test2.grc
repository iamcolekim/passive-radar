options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 32*1024
  states: {}
- name: avg
  id: variable_qtgui_range
  parameters:
    label: avg
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: centre_freq
  id: variable
  parameters:
    value: 1e9
  states: {state: disabled}
- name: centre_freq
  id: variable_qtgui_range
  parameters:
    start: 800e6
    step: 20e6
    stop: 2700e6
    value: 800e6
  states: {state: disabled}
- name: channel_freq
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: cut
  id: variable_qtgui_range
  parameters:
    label: cut
    rangeType: int
    start: '0'
    step: '10000'
    stop: int(samp_rate/2)
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Centre Frequency
    start: 87.9e6
    step: 200e3
    stop: 107.9e6
    value: 88.1e6
  states: {}
- name: mult
  id: variable_qtgui_range
  parameters:
    label: mult
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: mult2
  id: variable_qtgui_range
  parameters:
    label: mult2
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: variable_modulate_vector_0
  id: variable_modulate_vector
  parameters: {}
  states: {state: disabled}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,10
    label: Volume (dB)
    start: '0'
    step: '10'
    stop: '10000'
    value: '0'
  states: {}
- name: adapt_lms_filter_xx_0
  id: adapt_lms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: '0.0003'
    num_taps: int(N/64)
    reset: 'False'
    skip: '0'
    type: cc
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: volume
    type: complex
  states: {state: disabled}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: volume
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /Users/ibrahimsweidan/Downloads/880M/4_22pm/9f_880M_01_11_car_2.cs8
    length: '200000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /Users/ibrahimsweidan/Downloads/880M/4_22pm/63_880M_01_11_car_2.cs8
    length: '200000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: avg
    max_iter: '1000000'
    scale: '1'
    type: float
    vlen: N
  states: {state: disabled}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: 1/10
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: avg
    max_iter: '4000'
    scale: 1/avg
    type: float
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: mult
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: mult2
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_2
  id: blocks_multiply_const_vxx
  parameters:
    const: mult
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_3
  id: blocks_multiply_const_vxx
  parameters:
    const: mult
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: N
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: N
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
    vlen: N
  states: {state: disabled}
- name: blocks_sub_xx_0_1
  id: blocks_sub_xx
  parameters:
    type: complex
    vlen: N
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0, 0)
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0)*int(N/4)+(1,1)*int(N/4)
    vlen: N
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_1_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: dc_blocker_xx_0_0_0
  id: dc_blocker_xx
  parameters:
    length: '200000'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_1_0
  id: dc_blocker_xx
  parameters:
    length: '100'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_corr_est_cc_1
  id: digital_corr_est_cc
  parameters:
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_pn_correlator_cc_0
  id: digital_pn_correlator_cc
  parameters:
    mask: '0'
    seed: '1'
  states: {state: disabled}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: gr_digital_rf_vector_aggregate_0
  id: gr_digital_rf_vector_aggregate
  parameters:
    agg: mean
    agg_op: take
    agg_op_args: (0,)
    input: fc32
    max_nagg: '0'
    nagg: '1'
    take_index: '0'
    vlen: '1'
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=000000000000000066a062dc226b169f"'
    bb_gain0: '20'
    freq0: centre_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '10'
    fac_size: '512'
    sampRate: samp_rate
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: N
    srate: samp_rate
    type: float
    ymax: 6e6
    ymin: '-6e6'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"avg"'
    size: N
    srate: samp_rate
    type: float
    ymax: 6e6
    ymin: '-6e6'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Correlate"'
    size: N
    srate: samp_rate
    type: float
    ymax: 6e6
    ymin: '-6e6'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Ignore"'
    size: N
    srate: samp_rate
    type: complex
    update_time: '2'
    ymax: 6e6
    ymin: '-6e6'
  states: {}

connections:
- [adapt_lms_filter_xx_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [adapt_lms_filter_xx_0, '1', blocks_stream_to_vector_0_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_1_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_sub_xx_0_0_0_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_mag_0_0_1, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_sub_xx_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_delay_1, '0', adapt_lms_filter_xx_0, '1']
- [blocks_delay_1_0, '0', dc_blocker_xx_1, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_sub_xx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', dc_blocker_xx_1_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_delay_1_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_multiply_const_vxx_1_3, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0_0_0_0, '1']
- [blocks_moving_average_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_stream_to_vector_0_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_multiply_const_vxx_1_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1_3, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0, '0', fft_vxx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_sub_xx_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_sub_xx_0_1, '1']
- [blocks_stream_to_vector_0_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_sub_xx_0_0_0_0, '1']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_sub_xx_0, '0', dc_blocker_xx_0, '0']
- [blocks_sub_xx_0_0, '0', dc_blocker_xx_0, '0']
- [blocks_sub_xx_0_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_sub_xx_0_0_0_0, '0', blocks_vector_to_stream_1_0, '0']
- [blocks_sub_xx_0_1, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_vector_to_stream_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_sub_xx_0_0_0_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_vector_to_stream_1_0, '0', dc_blocker_xx_0_0_0, '0']
- [blocks_vector_to_stream_1_0, '0', high_pass_filter_0, '0']
- [blocks_vector_to_stream_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_1_0_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_vector_to_stream_1_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_1_0_0_0, '0', blocks_complex_to_mag_0_0_1, '0']
- [blocks_vector_to_stream_1_0_0_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_vector_to_stream_1_0_1, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [dc_blocker_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [dc_blocker_xx_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_1, '0', adapt_lms_filter_xx_0, '0']
- [dc_blocker_xx_1, '0', blocks_stream_to_vector_0, '0']
- [dc_blocker_xx_1_0, '0', adapt_lms_filter_xx_0, '1']
- [dc_blocker_xx_1_0, '0', blocks_delay_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_0_0_0, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_1_0_0_0, '0']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_1_0_1, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
